# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\bin\MAX_BLE_V5_V01.1.0.bin  .\obj\Project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F070,OFF =0,ON =1,FreeRTOS,TEST VIRTUAL_DISPLAY  IOT_METER, LOCK = 0, UNLOCK = 1
  c misc: --C99
  c include: ..\Libraries\CMSIS\ST\STM32F0xx\Source\Templates\arm;..\Libraries\CMSIS\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Project;..\Libraries\CMSIS\Include;..\mqtt;..\src\User_Audio_Task;..\src\User_Com_Task;..\src\User_Control_Task;..\src\User_Display_Task;..\src\User_Drive;..\src\User_Main_Task;..\src\User_NFC_Task;..\src\User_NFC_Task\INC_17550;..\src\User_Algorithm_Encryption
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x20000
  memory RVCT9: RAM 0x200000c0 size 0x4000
  link misc: --diag_suppress=L6329
  group Startup
    ../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_wwdg.c stm32f0xx_adc.c stm32f0xx_comp.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_crs.c stm32f0xx_usart.c
  group CMSIS
    ../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group User_Main_Task
    ../src/User_Main_Task/: main.c System_Config.c Universal_Init.c Gpio.c
  group User_Com_Task
    ../src/User_Com_Task/: ParseFrame.c User_Com_Task.c UART_3.c
  group User_Display_Task
    ../src/User_Display_Task/: Dis_Task.c LED_Others.c Ambient_Light_App.c iic.c
  group User_Control_Task
    ../src/User_Control_Task/: Control_task.c Flash.c IAP.c HandleTemperature.c StateUpdate.c TurnLightProcess.c
  group User_NFC_Task
    ../src/User_NFC_Task/: FM175XX.c MIFARE.c READER_API.c spi.c
  group User_Drive
    ../src/User_Drive/: variable.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0
